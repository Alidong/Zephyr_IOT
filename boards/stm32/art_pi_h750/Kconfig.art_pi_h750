## boards/stm32/art_pi_h750/Kconfig.art_pi_h750
```kconfig
# Copyright (c) 2023 STMicroelectronics
# SPDX-License-Identifier: Apache-2.0

config BOARD_ART_PI_H750
	select SOC_STM32H750XX
```
